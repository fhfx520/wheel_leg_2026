# Keil uVision project SuperCap2023.uvprojx, settings and files
target SuperCap2023 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32G474CETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.6.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: SuperCap2023 +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G474xx,USE_HAL_DRIVER,STM32G474xx,ARM_MATH_CM4,__FPU_PRESENT=1,__CC_ARM
  c include: ../Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../bsp;../math;../math/Include;../app
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x20018000 size 0x2000
  scatter file: SuperCap2023\SuperCap2023.sct
  group Application/MDK-ARM
    ./: startup_stm32g474xx.s
  group Application/User
    ../Src/: main.c gpio.c adc.c dma.c fdcan.c hrtim.c tim.c usart.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/CMSIS
    ../Src/: system_stm32g4xx.c
  group Application/Bsp
    ../bsp/: bsp_adc.c bsp_adc.h bsp_judge.c bsp_judge.h bsp_uart.c bsp_uart.h bsp_fdcan.c bsp_fdcan.h
  group math
    ../math/: filter.c filter.h KalmanFilter.c KalmanFilter.h pid.c pid.h arm_cortexM4lf_math.lib data_scope.c data_scope.h crc.c crc.h
  group app
    ../app/: debug.c debug.h power_ctrl_task.c power_ctrl_task.h control_def.h
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_fdcan.c stm32g4xx_hal_hrtim.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
software components: CMSIS:CORE 6.1.1
